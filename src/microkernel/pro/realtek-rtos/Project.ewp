# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None; default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CONFIG_PLATFORM_8711B; __IEEE_LITTLE_ENDIAN; RAM_LIMIT; _REALTEK_RTOS_
  ICCARM.CCDiagSuppress: Be006,Pa050,Pa039,Pa089,Pe014,Pe047,Pe068,Pe089,Pe167,Pe177,Pe186,Pe188,Pe375,Pe550,Pe550,Pe223,Pe549,Pe550
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\src; ..\..\src\mbedtls; ..\..\paho.mqtt.embedded; ..\..\paho.mqtt.embedded\src; ..\..\..\depends\realtek-rtos; ..\..\..\depends\realtek-rtos\os\freertos; ..\..\..\depends\realtek-rtos\os\freertos\freertos_v8.1.2\Source\include; ..\..\..\depends\realtek-rtos\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM4F; ..\..\..\depends\realtek-rtos\os\os_dep\include; ..\..\..\depends\realtek-rtos\common\api\network\include; ..\..\..\depends\realtek-rtos\common\api; ..\..\..\depends\realtek-rtos\common\api\at_cmd; ..\..\..\depends\realtek-rtos\common\api\platform; ..\..\..\depends\realtek-rtos\common\api\wifi; ..\..\..\depends\realtek-rtos\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\depends\realtek-rtos\common\api\wifi\rtw_wowlan; ..\..\..\depends\realtek-rtos\common\api\wifi\rtw_wpa_supplicant\wpa_supplicant; ..\..\..\depends\realtek-rtos\common\application; ..\..\..\depends\realtek-rtos\common\example; ..\..\..\depends\realtek-rtos\common\example\wlan_fast_connect; ..\..\..\depends\realtek-rtos\common\drivers\modules; ..\..\..\depends\realtek-rtos\common\drivers\sdio\realtek\sdio_host\inc; ..\..\..\depends\realtek-rtos\common\drivers\inic\rtl8711b; ..\..\..\depends\realtek-rtos\common\drivers\usb_class\device; ..\..\..\depends\realtek-rtos\common\drivers\usb_class\device\class; ..\..\..\depends\realtek-rtos\common\drivers\wlan\realtek\include; ..\..\..\depends\realtek-rtos\common\drivers\wlan\realtek\src\osdep; ..\..\..\depends\realtek-rtos\common\drivers\wlan\realtek\src\hci; ..\..\..\depends\realtek-rtos\common\drivers\wlan\realtek\src\hal; ..\..\..\depends\realtek-rtos\common\drivers\wlan\realtek\src\hal\rtl8711b; ..\..\..\depends\realtek-rtos\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\..\..\depends\realtek-rtos\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\depends\realtek-rtos\common\network; ..\..\..\depends\realtek-rtos\common\network\lwip\lwip_v1.4.1\port\realtek\freertos; ..\..\..\depends\realtek-rtos\common\network\lwip\lwip_v1.4.1\src\include; ..\..\..\depends\realtek-rtos\common\network\lwip\lwip_v1.4.1\src\include\lwip; ..\..\..\depends\realtek-rtos\common\network\lwip\lwip_v1.4.1\src\include\ipv4; ..\..\..\depends\realtek-rtos\common\network\lwip\lwip_v1.4.1\port\realtek; ..\..\..\depends\realtek-rtos\common\network\ssl\polarssl-1.3.8\include; ..\..\..\depends\realtek-rtos\common\network\ssl\ssl_ram_map\rom; ..\..\..\depends\realtek-rtos\common\test; ..\..\..\depends\realtek-rtos\common\utilities; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\app\monitor\include; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\cmsis; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\cmsis\device; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\fwlib; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\fwlib\include; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\fwlib\ram_lib\crypto; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\fwlib\rom_lib; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\swlib\os_dep\include; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\swlib\std_lib\include; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\swlib\std_lib\libc\include; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\swlib\std_lib\libc\rom\string; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\swlib\std_lib\libgcc\rtl8195a\include; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\swlib\rtl_lib; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\misc; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\misc\os; ..\..\..\depends\realtek-rtos\common\mbed\api; ..\..\..\depends\realtek-rtos\common\mbed\hal; ..\..\..\depends\realtek-rtos\common\mbed\hal_ext; ..\..\..\depends\realtek-rtos\common\mbed\targets\cmsis\rtl8711b; ..\..\..\depends\realtek-rtos\common\mbed\targets\hal\rtl8711b
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\inc; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\cmsis; ..\..\..\depends\realtek-rtos\soc\realtek\8711b\swlib\os_dep\include; ..\..\..\depends\realtek-rtos\os\freertos\freertos_v8.1.2\Source\include; ..\..\..\depends\realtek-rtos\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM4F; ..\..\src
  OBJCOPY.OOCOutputFile: Project.srec
  prebuild: CSCRIPT  "..\..\..\depends\realtek-rtos\soc\realtek\8711b\misc\iar_utility\common\prebuild.vbs" "$PROJ_DIR$" "1" "0x08080000"
  postbuild: CSCRIPT  "..\..\..\depends\realtek-rtos\soc\realtek\8711b\misc\iar_utility\common\postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$"
  ILINK.IlinkOutputFile: application.axf
  ILINK.IlinkKeepSymbols: bootloader
  ILINK.IlinkIcfFile: image2.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect realloc=pvPortReAlloc; --redirect free=vPortFree; --redirect sprintf=rtl_sprintf; --redirect snprintf=rtl_snprintf; --redirect vsnprintf=rtl_vsnprintf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group microkernel
    ../../src/: access_domain_bus.c access_domain_bus.h ase_support.c ase_support.h bscJSON.c bscJSON.h das_transport.c das_transport.h dev_protocol_def.h ezdev_sdk_kerne_queuel.c ezdev_sdk_kerne_queuel.h ezdev_sdk_kernel.c ezdev_sdk_kernel_access.c ezdev_sdk_kernel_access.h ezdev_sdk_kernel_common.c ezdev_sdk_kernel_common.h ezdev_sdk_kernel_event.c ezdev_sdk_kernel_event.h ezdev_sdk_kernel_ex.c ezdev_sdk_kernel_ex.h ezdev_sdk_kernel_extend.c ezdev_sdk_kernel_extend.h ezdev_sdk_kernel_inner.c ezdev_sdk_kernel_inner.h ezdev_sdk_kernel_platform.c ezdev_sdk_kernel_platform.h ezdev_sdk_kernel_risk_control.c ezdev_sdk_kernel_risk_control.h ezdev_sdk_kernel_xml_parser.c ezdev_sdk_kernel_xml_parser.h ezxml.c ezxml.h json_parser.c json_parser.h lbs_transport.c lbs_transport.h mkernel_internal_error.h sdk_kernel_def.c sdk_kernel_def.h utils.c utils.h
    ../../paho.mqtt.embedded/: MQTTClient.c MQTTClient.h MQTTNet.c MQTTNet.h
    ../../paho.mqtt.embedded/src/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group microkernel/mbedtls
    ../../src/mbedtls/: aes.c aes.h aesni.c aesni.h asn1.h asn1parse.c bignum.c bignum.h bn_mul.h check_config.h cipher.h config.h ctr_drbg.c ctr_drbg.h ecdsa.h ecp.h havege.c havege.h md.c md.h md2.c md2.h md4.c md4.h md5.c md5.h md_internal.h md_wrap.c oid.c oid.h padlock.c padlock.h pk.h pk_internal.h platform.c platform.h platform_time.h ripemd160.c ripemd160.h rsa.c rsa.h sha1.c sha1.h sha256.c sha256.h sha512.c sha512.h threading.h x509.h
